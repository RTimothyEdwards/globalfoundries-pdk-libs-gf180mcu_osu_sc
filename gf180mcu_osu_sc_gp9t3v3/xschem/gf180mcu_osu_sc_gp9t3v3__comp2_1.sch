v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
N 340 -390 800 -390 {lab=VDD}
N 800 -390 800 -290 {lab=VDD}
N 770 -290 800 -290 {lab=VDD}
N 1030 -390 1290 -390 {lab=VDD}
N 1290 -490 1290 -390 {lab=VDD}
N 1220 -490 1290 -490 {lab=VDD}
N 1290 -390 1400 -390 {lab=VDD}
N 1400 -390 1400 -350 {lab=VDD}
N 1380 -350 1400 -350 {lab=VDD}
N 1750 -520 1790 -520 {lab=VDD}
N 1790 -520 1790 -400 {lab=VDD}
N 1530 -400 1790 -400 {lab=VDD}
N 1400 -400 1400 -390 {lab=VDD}
N 1790 -400 1940 -400 {lab=VDD}
N 1940 -400 1940 -350 {lab=VDD}
N 1910 -350 1940 -350 {lab=VDD}
N 1530 -400 1530 -270 {lab=VDD}
N 1530 -270 1630 -270 {lab=VDD}
N 1630 -270 1630 -220 {lab=VDD}
N 1610 -220 1630 -220 {lab=VDD}
N 1030 -390 1030 -270 {lab=VDD}
N 1030 -270 1220 -270 {lab=VDD}
N 1220 -270 1220 -220 {lab=VDD}
N 1190 -220 1220 -220 {lab=VDD}
N 800 -290 800 -150 {lab=VDD}
N 770 -150 800 -150 {lab=VDD}
N 340 30 790 30 {lab=VSS}
N 790 -110 790 30 {lab=VSS}
N 770 -110 790 -110 {lab=VSS}
N 790 -250 790 -110 {lab=VSS}
N 770 -250 790 -250 {lab=VSS}
N 790 -110 1200 -110 {lab=VSS}
N 1200 -180 1200 -110 {lab=VSS}
N 1190 -180 1200 -180 {lab=VSS}
N 1200 -110 1620 -110 {lab=VSS}
N 1620 -180 1620 -110 {lab=VSS}
N 1610 -180 1620 -180 {lab=VSS}
N 1680 -180 1920 -180 {lab=VSS}
N 1920 -310 1920 -180 {lab=VSS}
N 1910 -310 1920 -310 {lab=VSS}
N 1920 -480 1920 -310 {lab=VSS}
N 1750 -480 1920 -480 {lab=VSS}
N 1680 -280 1680 -180 {lab=VSS}
N 1440 -280 1680 -280 {lab=VSS}
N 1380 -310 1380 -280 {lab=VSS}
N 1440 -450 1440 -280 {lab=VSS}
N 1220 -450 1440 -450 {lab=VSS}
N 420 -290 470 -290 {lab=B1}
N 420 -490 420 -290 {lab=B1}
N 420 -490 920 -490 {lab=B1}
N 880 -270 960 -270 {lab=#net1}
N 960 -350 960 -270 {lab=#net1}
N 960 -350 1080 -350 {lab=#net1}
N 880 -470 880 -270 {lab=#net1}
N 880 -470 920 -470 {lab=#net1}
N 340 -230 430 -230 {lab=B0}
N 430 -220 430 -150 {lab=B0}
N 430 -150 470 -150 {lab=B0}
N 430 -220 890 -220 {lab=B0}
N 390 -270 470 -270 {lab=A1}
N 340 -170 390 -170 {lab=A1}
N 390 -270 390 -170 {lab=A1}
N 340 -120 430 -120 {lab=A0}
N 430 -130 430 -120 {lab=A0}
N 430 -130 470 -130 {lab=A0}
N 770 -130 860 -130 {lab=#net2}
N 860 -200 860 -130 {lab=#net2}
N 860 -200 890 -200 {lab=#net2}
N 860 -130 1280 -130 {lab=#net2}
N 1280 -200 1280 -130 {lab=#net2}
N 1280 -200 1310 -200 {lab=#net2}
N 1190 -200 1240 -200 {lab=#net3}
N 1240 -290 1240 -200 {lab=#net3}
N 1060 -290 1240 -290 {lab=#net3}
N 1060 -330 1060 -290 {lab=#net3}
N 1060 -330 1080 -330 {lab=#net3}
N 1220 -470 1330 -470 {lab=#net4}
N 1330 -520 1330 -470 {lab=#net4}
N 1330 -520 1450 -520 {lab=#net4}
N 1380 -330 1410 -330 {lab=#net5}
N 1410 -330 1410 -260 {lab=#net5}
N 1310 -260 1410 -260 {lab=#net5}
N 1310 -260 1310 -220 {lab=#net5}
N 1410 -500 1410 -330 {lab=#net5}
N 1410 -500 1450 -500 {lab=#net5}
N 1760 -500 2000 -500 {lab=L}
N 1760 -500 1760 -380 {lab=L}
N 1610 -380 1760 -380 {lab=L}
N 1610 -380 1610 -350 {lab=L}
N 1610 -200 1660 -200 {lab=E}
N 1660 -290 1660 -200 {lab=E}
N 1570 -290 1660 -290 {lab=E}
N 1570 -330 1570 -290 {lab=E}
N 1570 -330 1610 -330 {lab=E}
N 1660 -200 2000 -200 {lab=E}
N 1910 -330 2000 -330 {lab=G}
N 1400 -400 1530 -400 {lab=VDD}
N 800 -390 1030 -390 {lab=VDD}
N 1620 -180 1680 -180 {lab=VSS}
N 1380 -280 1440 -280 {lab=VSS}
N 340 -290 420 -290 {lab=B1}
N 770 -270 880 -270 {lab=#net1}
N 430 -230 430 -220 {lab=B0}
N 1750 -500 1760 -500 {lab=L}
C {my_nxor.sym} 620 -270 0 0 {name=x1}
C {my_xor.sym} 620 -130 0 0 {name=x2}
C {my_nand.sym} 1040 -200 0 0 {name=x3}
C {my_nand.sym} 1230 -330 0 0 {name=x4}
C {my_xor.sym} 1600 -500 0 0 {name=x5}
C {my_nor.sym} 1070 -470 0 0 {name=x6}
C {my_nor.sym} 1460 -200 0 0 {name=x7}
C {my_nor.sym} 1760 -330 0 0 {name=x8}
C {devices/iopin.sym} 340 -390 2 0 {name=p10 lab=VDD
}
C {devices/ipin.sym} 340 -290 0 0 {name=p5 lab=B1

}
C {devices/ipin.sym} 340 -230 0 0 {name=p1 lab=B0


}
C {devices/ipin.sym} 340 -170 0 0 {name=p2 lab=A1



}
C {devices/iopin.sym} 340 30 2 0 {name=p11 lab=VSS



}
C {devices/ipin.sym} 340 -120 0 0 {name=p12 lab=A0


}
C {devices/opin.sym} 2000 -500 0 0 {name=p3 lab=L
}
C {devices/opin.sym} 2000 -330 0 0 {name=p4 lab=G

}
C {devices/opin.sym} 2000 -200 0 0 {name=p6 lab=E
}
